## app/dts/bindings/behaviors/zmk,behavior-mouse-scroll.yaml
```yaml
description: Mouse Scroll behavior

compatible: "zmk,behavior-mouse-scroll"

include: one_param.yaml
```
